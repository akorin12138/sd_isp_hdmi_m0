# Keil uVision project cm0.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: cm0
  AfterMake: fromelf -cvf .\Objects\cm0.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\Objects\cm0.axf -o code.txt
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c include: .\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./Source/: startup_CMSDK_CM0.s code_def.c code_def.h keyboard.c main.c handler.c isp.c isp.h
